SRC_URI += "file://user_2021-10-27-11-04-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

